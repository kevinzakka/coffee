Commit message: Add some basic props.

File: coffee/models/props/assets/ball/ball-template.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link baseLink: geometry collision sphere radius={RADIUS}; visual sphere radius={RADIUS}
